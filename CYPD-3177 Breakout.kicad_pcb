# Repository Hugoyhu/CYPD3177-Breakout

File README.md:

# CYPD3177-Breakout
Small 2-layer fixed USB-C PD Power Sink with CYPD3177. Breadboard friendly design, and can easily be assembled on a hot plate if you have a stencil.

The board provides a fixed output of 9V1A using the CYPD3177 chipset. It's highly flexible, allowing USB-C Charging up to 15W and USB-C PD up to 100W. Unlike many other chips available, it does not require any firmware nor flashing, and power settings are configured with pullup and pulldown resistors. This board is set to 9V @ 1A, to ensure maximum compatibility with most PD-capable bricks. It's very compact, measuring less than 22x32mm with breadboard-friendly mounting, an affordable 2-layer design, and single side SMD component placement. 

The board is more flexible than off-the-shelf PD boards based on chinese chipsets. They usually only have four pins for mounting, but this board is more mechanically sturdy due to the opposing pins on either side of the board.

You can also modify the design to add switches to configure requested voltage/current during power-on.

*As a precaution: while this board is breadboard friendly, typical solderless breadboards are only rated up to _5V @ 1A_. Do _not_ use this on a solderless breadboard.*
Also, it's important to note the maximum current and voltage that parts on the board can tolerate. For example, if you are looking to adapt the design for a higher current setting, it may be worth considering alternative output connectors: standard 2.54mm headers are only rated for <3A typically. In addition, not all USB-C connectors are rated up to 5A, and not all passives are rated for high voltage tolerance.

## KiCad design CYPD-3177 Breakout.kicad_pcb

Board: 2 copper layers, 21.3 x 31.5 mm, 25 parts (2 on the bottom side), 16 nets.

Parts:
C1, C2: 390pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 3.3uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C6, C9: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: 15V; D_SOD-323F
D2: LED_Small; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB-C Power; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J4: Conn_01x12; PinHeader_1x12_P2.54mm_Vertical
Q1, Q2: DMP3013SFV; Diodes_PowerDI3333-8
R1, R3: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R6: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 47K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 2K4; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: CYPD3177; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm

Connections:
+3V3: C6.1, C7.1, C8.1, R1.1, R3.1, U1.23 (VDDD)
/CC1: C1.1, J1.A5 (CC1), U1.15 (CC1)
/CC2: C2.1, J1.B5 (CC2), U1.14 (CC2)
/D+: J1.A6 (D+), J1.B6 (D+), U1.17 (D+)
/D-: J1.A7 (D-), J1.B7 (D-), U1.16 (D-)
/VBUSIN: C3.1, C4.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q1.5 (D), R5.1, U1.18 (VBUS_IN)
/VBUSOUT: C9.1, J2.1, J2.2, J2.3, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J2.11, J2.12, Q2.5 (D)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, D2.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J4.1, J4.2, J4.3, J4.4, J4.5, J4.6, J4.7, J4.8, J4.9, J4.10, J4.11, J4.12, R2.2, R4.2, U1.1 (VBUS_MIN), U1.6 (ISNK_FINE), U1.19 (GND), U1.22 (VSS), U1.25 (EPAD)
unnamed: C4.2, D1.2 (A), Q1.4 (G), Q2.4 (G), R5.2, R6.1, R7.2
unnamed: D1.1 (K), Q1.1 (S), Q1.2 (S), Q1.3, Q2.1 (S), Q2.2, Q2.3 (S), R7.1
unnamed: D2.2 (A), R8.2
unnamed: R8.1, U1.9 (FAULT)
unnamed: R1.2, R2.1, U1.5 (ISNK_COARSE)
unnamed: R6.2, U1.3 (VBUS_FET_EN)
unnamed: R3.2, R4.1, U1.2 (VBUS_MAX)
unnamed: C5.1, U1.24 (VCCD)

## Commit log

2026-01-11 Add files via upload
    add image
2026-01-11 [ImgBot] Optimize images
    *Total -- 3,938.63kb -> 3,728.13kb (5.34%)
    /CYPD3177 Breakout Schematic.png -- 493.07kb -> 336.99kb (31.65%)
    /USBCDecoyBoard.jpg -- 3,445.56kb -> 3,391.14kb (1.58%)
